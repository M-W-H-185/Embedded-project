# Keil uVision project os_stc8h_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 呼吸灯pwm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\XmRTOS
  group muc
    ./: STARTUP.A51 main.c
    ./XmRTOS/: os_task.c os_task.h os_mcu.asm os_queue.c os_queue.h
